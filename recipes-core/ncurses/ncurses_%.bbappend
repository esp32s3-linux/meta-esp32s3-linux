# SPDX-License-Identifier: MIT

# The external no-MMU uClibc-ng configuration does not provide wint_t.
ENABLE_WIDEC:xtensa = "false"
